<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\build\uart_send_demo\fire_uart_send_demo.ewp</path>
  </project>
  <batchBuild/>
</workspace>


