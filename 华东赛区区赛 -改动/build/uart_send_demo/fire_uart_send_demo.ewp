# IAR project fire_uart_send_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: E:\git\oschina\camera_code\fire_kinetis_new\Prj\IAR\config files\fire_ROM_K60N512.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  group app
    ../../src/projects/fire_uart_send_demo/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/AT24C02/: AT24C02.c
    ../../src/drivers/BALANCE/: BALANCE.c
    ../../src/drivers/dac/: dac.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/DIRECTION/: DIRECTION.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/GLOBAL/: GLOBAL.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/i2c/: i2c.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/pmc/: pmc.c
    ../../src/drivers/rtc/: rtc.c
    ../../src/drivers/sdhc/: sdhc.c
    ../../src/drivers/SPEED/: SPEED.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/projects/fire_uart_send_demo/: include.h isr.h
    ../../src/platforms/: k60_fire.h
