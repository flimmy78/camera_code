# IAR project fire_gpio_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\sd; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\projects\fire_gpio_demo; ..\..\build; ..\..\src\HWdrivers\Nokia5110_LCD\inc; ..\..\src\HWdrivers\LED
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: E:\freescale\bitbucket_code\fire_kinetis\build\config files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  ICCARM.CCDefines: NDEBUG; IAR; TWR_K60N512
  ICCARM.CCIncludePath2: ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\projects\fire_gpio_demo; ..\..\build; ..\..\src\HWdrivers\Nokia5110_LCD\inc
  ILINK.IlinkIcfFile: E:\freescale\野火-小霸王系列光盘\fire_Kinetis\build\config files\fire_RAM_K60N512.icf
  group app
    ../../src/projects/fire_gpio_demo/: init.c isr.c main.c
  group header
    ../../src/cpu/: clk_cfg.h
    ../../src/common/: common.h
    ../../src/projects/fire_gpio_demo/: include.h isr.h
  group HWdrivers/Camera/SCCB
    ../../src/HWdrivers/Camera/SCCB/: sccb.c
  group HWdrivers/LED
    ../../src/HWdrivers/LED/: LED_CORE.c LED_CORE.h
  group HWdrivers/Nokia5110_LCD
    ../../src/HWdrivers/Nokia5110_LCD/inc/: bmp_pixel.h english_6x8_pixel.h nokia_5110.h write_chinese_string_pixel.h
    ../../src/HWdrivers/Nokia5110_LCD/src/: nokia_5110.c
  group LessChange/common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group LessChange/cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group LessChange/drivers
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
