# IAR project fire_adc_demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fire_gpio_demo.hex
  ILINK.IlinkOutputFile: fire_gpio_demo.out
  ILINK.IlinkIcfFile: ..\config files\128KB_Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\config files\fire_ROM_K60N512.icf
  group app
    ../../src/projects/fire_adc_demo/: isr.c main.c
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/projects/fire_adc_demo/: include.h isr.h
