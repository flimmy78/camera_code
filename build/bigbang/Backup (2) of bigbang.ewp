# IAR project Backup (2) of bigbang.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; DEBUG; TWR_K60N512; ARM_MATH_CM4
  ICCARM.CCIncludePath2: ..\..\src\projects\bigbang; ..\..\src\common; ..\..\src\cpu; ..\..\src\cpu\headers; ..\..\src\platforms; ..\..\src\drivers; ..\..\src\drivers\adc; ..\..\src\drivers\dac; ..\..\src\drivers\dma; ..\..\src\drivers\AT24C02; ..\..\src\drivers\exti; ..\..\src\drivers\delay; ..\..\src\drivers\FTM; ..\..\src\drivers\gpio; ..\..\src\drivers\i2c; ..\..\src\drivers\LED; ..\..\src\drivers\lptmr; ..\..\src\drivers\mcg; ..\..\src\drivers\PIT; ..\..\src\drivers\pmc; ..\..\src\drivers\rtc; ..\..\src\drivers\uart; ..\..\src\drivers\wdog; ..\..\src\drivers\nokia_5110; ..\..\src\LIB\CMSIS; ..\..\src\LIB\FatFs; ..\..\build; ..\..\src\init
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: smartcar_lcd_demo.hex
  ILINK.IlinkOutputFile: smartcar_lcd_demo.out
  ILINK.IlinkIcfFile: ..\config files\512KB_Pflash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../src/init/: board.c board.h init.c init.h str2num.c str2num.h
    ../../src/drivers/: fire_drivers_cfg.h
    ../../src/projects/bigbang/: isr.c isr.h Kalman.c main.c
    ../../src/platforms/: k60_fire.h
  group common
    ../../src/common/: alloc.c assert.c io.c memtest.c printf.c queue.c startup.c stdlib.c uif.c
  group cpu
    ../../src/cpu/: arm_cm4.c crt0.s start.c sysinit.c vectors.c
  group drivers
    ../../src/drivers/adc/: adc.c
    ../../src/drivers/delay/: delay.c
    ../../src/drivers/dma/: dma.c
    ../../src/drivers/exti/: exti.c
    ../../src/drivers/FTM/: FTM.c
    ../../src/drivers/gpio/: gpio.c
    ../../src/drivers/LED/: LED.C LED_CORE.c
    ../../src/drivers/lptmr/: lptmr.c
    ../../src/drivers/mcg/: mcg.c
    ../../src/drivers/nokia_5110/: nokia_5110.c
    ../../src/drivers/PIT/: PIT.c
    ../../src/drivers/uart/: uart.c
    ../../src/drivers/wdog/: wdog.c
  group header
    ../../src/common/: common.h
    ../../src/projects/bigbang/: include.h
  group lib/CMSIS
    ../../src/LIB/CMSIS/: iar_cortexM4l_math.a
